# Keil uVision project Drivers.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: waterTank
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group application
    ./: main.c
  group inc
    ./: gpio_registers.h full_tank.h over_flow_tank.h seven_segment_display.h pattern.h servo_motor.h joystick.h triangular_wave.h led_blink.h thermistor.h lcd.h lcd_raw.h i2c.h ultrasonic.h
  group src
    ./: gpio_registers.c full_tank.c over_flow_tank.c seven_segment_display.c triangular_wave.c pattern.c servo_motor.c joystick.c led_blink.c thermistor.c lcd.c lcd_raw.c i2c.c ultrasonic.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
